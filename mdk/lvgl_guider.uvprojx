# Keil uVision project lvgl_guider.uvprojx, settings and files
target lvgl_guider flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_guider.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6B, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LV_CONF_INCLUDE_SIMPLE=1, CPU_MIMXRT1062DVL6B_cm7, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SD_ENABLED, SDK_OS_FREE_RTOS, __NXP_MSDK__
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: ../Core/board;../Core/source;../Core/CMSIS;../Core/component/gpio;../Core/component/lists;../Core/component/osa;../Core/component/serial_manager;../Core/component/uart;../../custom;../Core/device;../Core/drivers;../Core/fatfs/source;../Core/fatfs/source/fsl_sd_disk;../Core/freertos/freertos-kernel/include;../Core/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../generated;../../generated/guider_customer_fonts;../../generated/guider_fonts;../Core/lvgl;../Core/lvgl/lvgl;../Core/lvgl/lvgl/src;../Core/lvgl/lvgl/src/font;../Core/openh264/codec/api/svc;../Core/openh264/codec/common/inc;../Core/openh264/codec/decoder/core/inc;../Core/openh264/codec/decoder/plus/inc;../Core/sdmmc/host;../Core/sdmmc/inc;../Core/sdmmc/osa;../Core/source/freertos_libraries/abstractions/posix/include;../Core/source/freertos_libraries/c_sdk/standard/common/include/private;../Core/source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include;../Core/touchpanel;../Core/utilities;../Core/video;../Core/xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../Core/source;../Core/freertos/freertos-kernel/include
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062/arm/MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x1800000"
--remove
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h lvgl_support.c lvgl_support.h pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h
  group CMSIS
    ../Core/CMSIS/: cachel1_armv7.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/gpio
    ../Core/component/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/lists
    ../Core/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../Core/component/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    ../Core/component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk lv_conf_ext.h
  group device
    ../Core/device/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group doc
    ../Core/doc/: readme.md
  group drivers
    ../Core/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h fsl_usdhc.c fsl_usdhc.h
  group fatfs/source
    ../Core/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../Core/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group freertos/freertos-kernel
    ../Core/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../Core/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../Core/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../Core/freertos/freertos-kernel/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable
    ../Core/freertos/freertos-kernel/portable/: readme.txt
  group generated
    ../../generated/: events_init.c events_init.h generated.mk gui_guider.c gui_guider.h setup_scr_calculator.c setup_scr_calculator_sum.c setup_scr_chart.c setup_scr_map.c setup_scr_map_1.c setup_scr_map_2.c setup_scr_scrStackedAreaChart.c widgets_init.c widgets_init.h
  group generated\guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h guider_customer_fonts.mk
  group generated\guider_fonts
    ../../generated/guider_fonts/: fonts_list.mk guider_fonts.mk lv_font_Acme_Regular_17.c lv_font_Acme_Regular_20.c lv_font_montserratMedium_10.c lv_font_montserratMedium_12.c lv_font_montserratMedium_13.c lv_font_montserratMedium_14.c lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c
  group generated\images
    ../../generated/images/: images.mk images_list.mk images_md5.json lottie_list.mk _2_alpha_480x272.c _47cff9b8ea795bfa_alpha_272x272.c _5e6b6b379dd3b607_alpha_272x272.c _5f9b260e83842005_alpha_272x272.c _test_alpha_476x272.c _test_alpha_480x272.c
  group lvgl/lvgl
    ../Core/lvgl/lvgl/: ChangeLogKSDK.txt LICENCE.txt lvgl.h
  group lvgl/lvgl/src/core
    ../Core/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw/arm2d
    ../Core/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.h
  group lvgl/lvgl/src/draw
    ../Core/lvgl/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../Core/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../Core/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_line.c lv_draw_vglite_line.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_vglite_buf.c lv_vglite_buf.h lv_vglite_utils.c lv_vglite_utils.h
  group lvgl/lvgl/src/draw/renesas
    ../Core/lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c lv_gpu_d2_ra6m3.h
  group lvgl/lvgl/src/draw/sdl
    ../Core/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../Core/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/sw
    ../Core/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/lvgl/src/draw/swm341_dma2d
    ../Core/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../Core/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../Core/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/layouts
    ../Core/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/libs/barcode
    ../Core/lvgl/lvgl/src/extra/libs/barcode/: code128.c code128.h lv_barcode.c lv_barcode.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../Core/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../Core/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../Core/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../Core/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/lvgl/src/extra/libs/gif
    ../Core/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs
    ../Core/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/png
    ../Core/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../Core/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/lvgl/src/extra/libs/rlottie
    ../Core/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../Core/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/lvgl/src/extra
    ../Core/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/others/fragment
    ../Core/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
  group lvgl/lvgl/src/extra/others/gridnav
    ../Core/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/ime
    ../Core/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
  group lvgl/lvgl/src/extra/others/imgfont
    ../Core/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/lvgl/src/extra/others
    ../Core/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/monkey
    ../Core/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/msg
    ../Core/lvgl/lvgl/src/extra/others/msg/: lv_msg.c lv_msg.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../Core/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/themes/basic
    ../Core/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../Core/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes
    ../Core/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/mono
    ../Core/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets/analogclock
    ../Core/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c lv_analogclock.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../Core/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../Core/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/carousel
    ../Core/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c lv_carousel.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../Core/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../Core/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/dclock
    ../Core/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../Core/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../Core/lvgl/lvgl/src/extra/widgets/keyboard/: chinese_library.h lv_keyboard.c lv_keyboard.h lv_zh_keyboard.c lv_zh_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../Core/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../Core/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets
    ../Core/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../Core/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../Core/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../Core/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/radiobtn
    ../Core/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c lv_radiobtn.h
  group lvgl/lvgl/src/extra/widgets/span
    ../Core/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../Core/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../Core/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../Core/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/textprogress
    ../Core/lvgl/lvgl/src/extra/widgets/textprogress/: lv_textprogress.c lv_textprogress.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../Core/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/video
    ../Core/lvgl/lvgl/src/extra/widgets/video/: lv_video.c lv_video.h
  group lvgl/lvgl/src/extra/widgets/win
    ../Core/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/font
    ../Core/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../Core/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src
    ../Core/lvgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/lvgl/src/misc
    ../Core/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../Core/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group openh264/codec/api/svc
    ../Core/openh264/codec/api/svc/: codec_api.h codec_app_def.h codec_def.h codec_ver.h
  group openh264/codec/common/inc
    ../Core/openh264/codec/common/inc/: asmdefs_mmi.h copy_mb.h cpu.h cpu_core.h crt_util_safe_x.h deblocking_common.h expand_pic.h golomb_common.h intra_pred_common.h ls_defines.h macros.h mc.h measure_time.h memory_align.h sad_common.h typedefs.h utils.h version.h wels_common_defs.h wels_const_common.h welsCodecTrace.h WelsList.h WelsLock.h WelsTask.h WelsTaskThread.h WelsThread.h WelsThreadLib.h WelsThreadPool.h
  group openh264/codec/decoder/core/inc
    ../Core/openh264/codec/decoder/core/inc/: au_parser.h bit_stream.h cabac_decoder.h deblocking.h dec_frame.h dec_golomb.h decode_mb_aux.h decode_slice.h decoder.h decoder_context.h decoder_core.h error_code.h error_concealment.h fmo.h get_intra_predictor.h manage_dec_ref.h mb_cache.h memmgr_nal_unit.h mv_pred.h nal_prefix.h nalu.h parameter_sets.h parse_mb_syn_cabac.h parse_mb_syn_cavlc.h pic_queue.h picture.h rec_mb.h slice.h vlc_decoder.h wels_common_basis.h wels_const.h wels_decoder_thread.h
  group openh264/codec/decoder/plus/inc
    ../Core/openh264/codec/decoder/plus/inc/: welsDecoderExt.h
  group sdmmc/host
    ../Core/sdmmc/host/: ChangeLogKSDK.txt fsl_sdmmc_host.c fsl_sdmmc_host.h
  group sdmmc/inc
    ../Core/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/osa
    ../Core/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/sd
    ../Core/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/src
    ../Core/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    ../Core/source/: ffconf.h FreeRTOS_POSIX_portable.h FreeRTOSConfig.h h264_dec.cpp h264_dec.h lv_conf.h lvgl_demo_utils.c lvgl_demo_utils.h lvgl_freertos.c lvgl_freertos.h lvgl_guider.c sdcard.c sdcard.h
  group source/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../Core/source/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group source/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../Core/source/freertos_libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group source/freertos_libraries/c_sdk/standard/common/include/private
    ../Core/source/freertos_libraries/c_sdk/standard/common/include/private/: iot_doubly_linked_list.h
  group source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include
    ../Core/source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h FreeRTOS_POSIX_types.h
  group source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/source
    ../Core/source/freertos_libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group startup
    startup/: startup_MIMXRT1062.S
  group touchpanel
    ../Core/touchpanel/: fsl_ft5406_rt.c fsl_ft5406_rt.h fsl_gt911.c fsl_gt911.h
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group video
    ../Core/video/: fsl_video_common.c fsl_video_common.h
  group xip
    ../Core/xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
target lvgl_guider flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6B NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_guider.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1062DVL6B, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, LV_CONF_INCLUDE_SIMPLE=1, CPU_MIMXRT1062DVL6B_cm7, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, SERIAL_PORT_TYPE_UART=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SD_ENABLED, SDK_OS_FREE_RTOS, __NXP_MSDK__
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ../Core/source;../Core/freertos/freertos-kernel/include
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062/arm/MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: as above
